# Keil uVision project Device-Debug.uvprojx, settings and files
target Device-Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S8-53M-dbg
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, DEVICE
  c misc: --cpp
  c include: ..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\ipv4;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\lwip;..\common\STM32Cube_F4\Drivers\CMSIS\Include;.\src\Hardware\HAL;.\src\Hardware\USBH;.\src\Hardware\FatFS;.\src\Hardware\USBD;.\src\Hardware\LwIP;..\..\sources
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
  group libs/CMSIS
    ../common/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f429xx.h
    ../common/STM32Cube_F4/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h
  group libs/FatFS
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group libs/HAL
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_usb.h
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group libs/LwIP
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c inet_chksum.c def.c ip.c timeouts.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c igmp.c icmp.c autoip.c dhcp.c etharp.c ip4_frag.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c netbuf.c err.c api_msg.c api_lib.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/include/lwip/: opt.h
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/test/unit/arch/: sys_arch.c
  group libs/USBD
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group libs/USBH
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Hardware
    ./src/Hardware/: EPROM.h EPROM.cpp Hardware.h Sound.cpp Sound.h DisplayHardware.inc Hardware.cpp Timer.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ./src/Hardware/FatFS/: ffconf.h usbh_diskio.c usbh_diskio.h
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL_IT.cpp
    ../common/Hardware/HAL/: HAL.h HAL_PINS.h cHAL.cpp cHAL_ADC3.cpp cHAL_CRC.cpp cHAL_DAC.cpp cHAL_EPROM.cpp cHAL_FSMC.cpp cHAL_OTP.cpp cHAL_PINS.cpp cHAL_RTC.cpp cHAL_SPI1.cpp cHAL_SRAM.cpp cHAL_TIM2.cpp cHAL_TIM6.cpp cHAL_TIM7.cpp cHAL_USBD.cpp
  group Hardware/LwIP
    ./src/Hardware/LwIP/: app_ethernet.cpp app_ethernet.h ethernetif.cpp ethernetif.h lwipopts.h
  group Hardware/USBD
    ./src/Hardware/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.cpp usbd_desc.h
  group Hardware/USBH
    ./src/Hardware/USBH/: usbh_conf.cpp usbh_conf.h
  group src
    ./src/: main.h defines.h device.cpp device.h Tables.h Globals.h main2.s main.cpp defines.cpp Tables.cpp Globals.cpp
    ../common/: cLog.cpp Log.h
  group Display
    ./src/Display/: Display.h Display.cpp Display_stm.cpp DisplayPrimitives.h Colors.h Painter.h Painter.cpp Painter_stm.cpp DisplayTypes.h Grid.cpp Grid.h Math3D.h WelcomeScreen.h PainterMem.h Symbols.h PainterMem.cpp Colors.cpp DisplayPrimitives.cpp WelcomeScreen.cpp Math3D.cpp PainterText.cpp PainterC.h Primitives.cpp Primitives.h
  group Display/font
    ./src/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group FDrive
    ./src/FDrive/: FDrive.cpp FDrive.h
  group FPGA
    ./src/FPGA/: FPGA.cpp FPGA.h FPGA_Types.h FPGA_Calibration.cpp FPGA_Settings.cpp Storage.cpp Storage.h
  group LAN
    ./src/LAN/: LAN.h LAN.cpp SocketTCP.h SocketTCP.cpp
  group Menu
    ./src/Menu/: FileManager.h Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsGraphics.h MenuItemsLogic.h MenuFunctions.cpp MenuDrawing.cpp FileManager.cpp MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: Definition.h PageCursors.h PageHelp.h PageMemory.h HelpContent.h HelpContentPages.h PageMeasures.h PageMemory.cpp PageCursors.cpp Definition.cpp PageDebug.cpp HelpContent.cpp PageChannels.cpp PageDebug.h PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageService.h PageService.cpp PageTime.cpp PageTrig.cpp
  group Panel
    ../common/Keyboard/: Controls.h cControls.cpp
    ./src/Panel/: Panel.h Panel.cpp PanelFunctions.cpp
  group Settings
    ./src/Settings/: SettingsTypes.h Settings.h SettingsChannel.h SettingsDisplay.h SettingsMemory.h SettingsTime.h SettingsService.h SettingsCursors.h SettingsDebug.h SettingsTrig.h SettingsMath.h SettingsTypes.cpp Settings.cpp SettingsChannel.cpp SettingsCursors.cpp SettingsDebug.cpp SettingsDisplay.cpp SettingsMeasures.cpp SettingsMeasures.h SettingsMemory.cpp SettingsService.cpp SettingsTime.cpp
    ../common/Settings/: cSettingsTypes.h
  group Utils
    ./src/Utils/: Strings.h Map.h Generator.h GlobalFunctions.h Math.h Measures.h ProcessingSignal.h Stack2500uint16.cpp Stack2500uint16.h CreateTables.py TablesLog.h TablesWindow.h Generator.cpp GlobalFunctions.cpp Map.cpp Math.cpp Measures.cpp ProcessingSignal.cpp Strings.cpp
  group VCP
    ./src/VCP/: VCP.h VCP.cpp
  group VCP/SCPI
    ./src/VCP/SCPI/: SCPI.h channelSCPI.cpp commonSCPI.cpp controlSCPI.cpp displaySCPI.cpp SCPI.cpp tbaseSCPI.cpp trigSCPI.cpp
