# Keil uVision project Device.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S8-53M +hex
  AfterMake: fromelf --bin --output .\S8-53M.bin .\Objects\s8-53M.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, DEVICE
  c misc: --cpp
  c include: ..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\ipv4;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\lwip;..\common\STM32Cube_F4\Drivers\CMSIS\Include;.\src\Hardware\HAL;.\src\Hardware\USBH;.\src\Hardware\FatFS;.\src\Hardware\USBD;.\src\Hardware\LwIP;..\..\sources
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
  group libs/CMSIS
    ../common/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f429xx.h
    ../common/STM32Cube_F4/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h
  group libs/FatFS
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group libs/HAL
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_usb.h stm32f4xx_hal_dma2d.h stm32f4xx_ll_fmc.h
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group libs/LwIP
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c inet_chksum.c def.c ip.c timeouts.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c igmp.c icmp.c autoip.c dhcp.c etharp.c ip4_frag.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c netbuf.c err.c api_msg.c api_lib.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/include/lwip/: opt.h
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../common/STM32Cube_F4/Middlewares/Third_Party/LwIP/test/unit/arch/: sys_arch.c
  group libs/USBD
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group libs/USBH
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Hardware
    ../common/Hardware/: Sound_.h Sound_.cpp Timer_.h Timer_.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ./src/Hardware/FatFS/: ffconf.h usbh_diskio.h
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL_IT.cpp
    ../common/Hardware/HAL/: HAL_.h HAL_.cpp HAL_ADC1_.cpp HAL_CRC_.cpp HAL_DAC1_.cpp HAL_DAC2_.cpp HAL_FMC_.cpp HAL_LTDC_.cpp HAL_OTP_.cpp HAL_PINS_.h HAL_PINS_.cpp HAL_ROM_.cpp HAL_RTC_.cpp HAL_SPI1_.cpp HAL_SPI5_.cpp HAL_TIM2_.cpp HAL_TIM6_.cpp HAL_TIM7_.cpp HAL_USBD_.cpp
  group Hardware/LwIP
    ./src/Hardware/LwIP/: app_ethernet.cpp app_ethernet.h ethernetif.cpp ethernetif.h lwipopts.h
  group Hardware/Memory
    ../common/Hardware/Memory/: ROM_.h ROM_.cpp ROM_Data_.cpp Sector_.h Sector_.cpp
    ./src/Hardware/Memory/: Sector.cpp
  group Hardware/USBD
    ./src/Hardware/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.cpp usbd_desc.h
  group Hardware/USBH
    ./src/Hardware/USBH/: usbh_conf.cpp usbh_conf.h
  group src
    ./src/: main.h defines.h device.cpp device.h Tables.h main2.s main.cpp Tables.cpp
    ../common/: defines_.h Log_.cpp Log_.h
  group Display
    ../common/Display/: Colors_.h Colors_.cpp Colors_stm_.cpp
    ./src/Display/: Colors_d.cpp Console.h Console.cpp Display.h Display.cpp Display_stm.cpp PainterData.h PainterData.cpp Warnings.h Warnings.cpp
  group Display/Font
    ../common/Display/Font/: font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font_.cpp Font_.h
  group Display/Painter
    ./src/Display/Painter/: DisplayPrimitives.h DisplayPrimitives.cpp
    ../common/Display/Painter/: Painter_.h Painter_.cpp Primitives_.h Primitives_.cpp Primitives_stm_.cpp Text_.h Text_.cpp
  group Display/Screen
    ./src/Display/Screen/: BottomPart.h BottomPart.cpp Grid.h Grid.cpp TopPart.h TopPart.cpp MemoryWindow.h MemoryWindow.cpp
  group FDrive
    ./src/FDrive/: FDrive.h FDrive_stm.cpp
  group FPGA
    ./src/FPGA/: FPGA.h FPGA.cpp FPGA_AutoFinder.h FPGA_AutoFinder.cpp FPGA_Calibration.cpp FPGA_Math.h FPGA_Math.cpp FPGA_Reader.h FPGA_Reader.cpp FPGA_Settings.cpp FPGA_Types.h
  group FPGA/Data
    ./src/FPGA/Data/: DataSettings.h DataSettings.cpp Preparator.h Preparator.cpp Storage.h Storage.cpp
  group LAN
    ./src/LAN/: LAN.h LAN.cpp SocketTCP.h SocketTCP.cpp
  group Menu
    ./src/Menu/: FileManager.h Menu.cpp Menu.h MenuFunctions.cpp MenuDrawing.cpp FileManager.cpp
  group Menu/Items
    ./src/Menu/Items/: MenuItems.h MenuItems.cpp MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: Definition.h HelpContent.h HelpContentPages.h PageCursors.cpp Definition.cpp HelpContent.cpp PageChannels.cpp PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageTime.cpp PageTrig.cpp
  group Menu/Pages/Debug
    ./src/Menu/Pages/Debug/: PageDebug.cpp PageADC.cpp PageAltShiftADC.cpp PageBalanceADC.cpp PageConsole.cpp PageRandomizer.cpp PageRegisters.cpp PageSerialNumber.cpp PageStretchADC.cpp
  group Menu/Pages/Memory
    ./src/Menu/Pages/Memory/: PageMemory.cpp PageExternal.cpp PageFileManager.cpp PageInternal.cpp PageLatest.cpp PageSetMask.cpp PageSetName.cpp
  group Menu/Pages/Service
    ./src/Menu/Pages/Service/: PageService.cpp PageLAN.cpp PageMath.cpp
  group Panel
    ../common/Panel/: Controls_.h Controls_.cpp
    ./src/Panel/: Panel.h Panel.cpp
  group Settings
    ./src/Settings/: Settings.h Settings.cpp SettingsNRST.h SettingsNRST.cpp SettingsTypes.cpp SettingsTypesGraphics.cpp SettingsCursors.cpp SettingsDisplay.cpp
    ../common/Settings/: SettingsTypes_.h
  group Utils
    ./src/Utils/: CreateTables.py Measures.h Measures.cpp ProcessingSignal.h ProcessingSignal.cpp
    ../common/Utils/: Debug_.h Debug_.cpp Math_.h Math_.cpp Mutex_.h Mutex_.cpp StringUtils_.h StringUtils_.cpp
  group Utils/Containers
    ../common/Utils/Containers/: Buffer_.h Buffer_.cpp Queue_.h Queue_.cpp String_.h String_.cpp Values_.h Values_.cpp
  group VCP
    ./src/VCP/: VCP.h VCP.cpp
  group VCP/SCPI
    ./src/VCP/SCPI/: SCPI.h channelSCPI.cpp commonSCPI.cpp controlSCPI.cpp displaySCPI.cpp SCPI.cpp tbaseSCPI.cpp trigSCPI.cpp
  group VCP/SCPI/Utils
    ./src/VCP/SCPI/Utils/: MapSCPI.h MapSCPI.cpp StringsSCPI.h StringsSCPI.cpp
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: S8-53M
  AfterMake: fromelf --bin --output .\S8-53M.bin .\Objects-Debug\s8-53M.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, DEBUG, DEVICE
  c misc: --cpp
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
