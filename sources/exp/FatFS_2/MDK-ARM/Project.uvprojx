# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I-Discovery
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ..\..\..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\Inc;..\..\..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Inc/: ffconf.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h usbh_conf.h usbh_diskio_dma.h
    ../Src/: main.c stm32f4xx_it.c usbh_conf.c usbh_diskio_dma.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group FatFS
    ../../../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff_gen_drv.h ff.c ff.h diskio.c diskio.h
  group USBH
    ../../../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
    ../../../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 5.4.0
