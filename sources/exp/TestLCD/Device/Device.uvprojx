# Keil uVision project Device.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S8-53M +hex
  AfterMake: fromelf --bin --output .\S8-53M.bin .\Objects\s8-53M.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, DEVICE
  c misc: --cpp
  c include: ..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\ipv4;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\common\Hardware\FatFS;..\common\Hardware\USBH;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\lwip;..\common\STM32Cube_F4\Drivers\CMSIS\Include;.\src\Hardware\HAL;.\src\Hardware\USBD;.\src\Hardware\LwIP;..\..\sources;..
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/CMSIS
    ../common/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f429xx.h
    ../common/STM32Cube_F4/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h
  group libs/HAL
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_usb.h stm32f4xx_hal_dma2d.h stm32f4xx_ll_fmc.h
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL_.h HAL_.cpp stm32f4xx_hal_conf.h HAL_DAC1_.cpp HAL_IT.cpp HAL_LTDC_.cpp HAL_PINS_.cpp HAL_PINS_.h HAL_FMC_.cpp
  group src
    ./src/: defines.h defines_.h device.cpp device.h main.cpp main.h
  group Display
    ./src/Display/: Colors_.cpp Colors_.h Display.cpp Display.h
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: S8-53M
  AfterMake: fromelf --bin --output .\S8-53M.bin .\Objects-Debug\s8-53M.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, DEBUG, DEVICE
  c misc: --cpp
  c include: ..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\ipv4;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\common\Hardware\FatFS;..\common\Hardware\USBH;..\common\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include\lwip;..\common\STM32Cube_F4\Drivers\CMSIS\Include;.\src\Hardware\HAL;.\src\Hardware\USBD;.\src\Hardware\LwIP;..\..\sources
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
