# Keil uVision project Panel-Debug.uvprojx, settings and files
target Panel-Debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L063C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Panel-dbg
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L063xx
  c include: .\src;.\src\Hardware\HAL;..\common\STM32Cube_L0\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\common\STM32Cube_L0\Drivers\CMSIS\Include;..\common\STM32Cube_L0\Drivers\STM32L0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group libs/HAL
    ../common/STM32Cube_L0/Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_cortex.h stm32l0xx_hal_dma.h stm32l0xx_hal_gpio.h stm32l0xx_hal_rcc.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h
    ../common/STM32Cube_L0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32l063xx.s system_stm32l0xx.cpp
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL_PINS.h HAL.cpp HAL_PINS.cpp HAL_SPI2.cpp HAL_TIM2.cpp stm32l0xx_hal_conf.h stm32l0xx_it.h stm32l0xx_it.cpp
  group src
    ./src/: main.cpp
  group Keyboard
    ./src/Keyboard/: Controls.cpp Controls.h Keyboard.cpp Keyboard.h
