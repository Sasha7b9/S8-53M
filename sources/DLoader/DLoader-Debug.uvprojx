# Keil uVision project DLoader-Debug.uvprojx, settings and files
target DLoader-Debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DLoader-dbg
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, LOADER
  c misc: --cpp
  c include: .\src;.\src\libs;.\src\Hardware\FatFS;.\src\Hardware\HAL;.\src\Hardware\USBH;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\CMSIS\Include;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DLoader.sct
  group libs/CMSIS
    ../common/STM32Cube_F4/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
    ../common/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h stm32f207xx.h system_stm32f2xx.h
  group libs/FatFS
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group libs/HAL
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_def.h stm32f4xx_ll_usb.h
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group libs/USBH
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Hardware
    ./src/Hardware/: Hardware.cpp Hardware.h Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ./src/Hardware/FatFS/: ffconf.h usbh_diskio.c usbh_diskio.h
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h stm32f4xx_it.h stm32f4xx_it.cpp
    ../common/Hardware/HAL/: HAL.h HAL_PINS.h cHAL.cpp cHAL_EPROM.cpp cHAL_PINS.cpp cHAL_SPI1.cpp cHAL_TIM6.cpp cHAL_TIM2.cpp cHAL_TIM7.cpp cHAL_FSMC.cpp
  group Hardware/USBH
    ./src/Hardware/USBH/: usbh_conf.h usbh_conf.cpp
  group src
    ./src/: defines.cpp defines.h main.cpp main.h
    ../common/: Log.h cLog.cpp
  group Display
    ./src/Display/: Colors.cpp Colors.h Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h PainterC.h PainterText.cpp PainterText.h
  group Display/font
    ./src/Display/font/: Font.cpp Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group FDrive
    ./src/FDrive/: FDrive.cpp FDrive.h
  group Panel
    ./src/Panel/: Controls.cpp Controls.h Panel.cpp Panel.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsTypes.h
    ../common/Settings/: cSettingsTypes.h
  group Utils
    ./src/Utils/: GlobalFunctions.cpp GlobalFunctions.h Math.cpp Math.h
